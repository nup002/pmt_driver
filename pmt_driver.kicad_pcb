# Repository nup002/pmt_driver

File README.md:

# PMT driver
-------------

The PMT driver is a complete system for operating and pulse height triggering on up to four photomultiplier tubes. 
It will output high-precision (92ps jitter typ.) trigger pulses from each channel as LVDS signals on cat5 ethernet cable.
Low-precision trigger pulses are combined with programmable logic so that channels can be set up in coincidence, veto, or any other 
configuration as required for the specific experimental setup.

Specifications and capabilities:
- Input voltage: 18V-36V, recommended 24V.
- Current consumption: 250mA
- Screw terminals for powering and controlling gain of four PMTs (designed for Hamamatsu H10425 series)
- Four LEMO input channels. Per channel:
  - 5.95mV/1µA amplifier (75.5dB). Operational range: 1MHz - 300MHz.
  - Pulse height discriminator (200ps jitter typ.) with adjustable discriminator level and pulse length output.
  - Discriminated pulse output as LVDS over RJ45 connector for standard cat5 ethernet cables. Pulses from each of the four channels are time-matched to +-5ps.
- TTL-level version of the discriminated pulses pass through optional delay lines.
- Discriminated pulses are combined with programmable logic, so that nearly any required experimental configuration can be implemented. 
- Final pulse is output over LVDS and TTL, with adjustable length.

## Programmable logic
There are four input channels on the PMT driver, designated CH0 to Ch3. CH0 and CH1 are designed as Pair A. CH2 and CH3 are designated as Pair B. 
The TTL pulses that are generated by each discriminator are combined in a block of programmable logic, where the configuration is set by DIP-switches. There are 
three blocks of DIP-switches. The signals of Pair A are combined in block 1. The signals of Pair B are combined in block 2. 
These two signals are then combined to one in block 3. This is the final output. 

The DIP switches works as lookup tables, and their configuration determine what the output of the block will be based on the logic state of the two input channels. 
Each block can therefore be set up to be any logic gate, such as AND, OR, NOR, XOR, NAND, etc, and also other non-standard logic gates.

## KiCad design pmt_driver.kicad_pcb

Parts:
C229, C230: C; C_0805
J1, J2, J13, J16, J18: Conn_Coaxial; LEMO_angled; MPN EPK.00.250.NTN
J3: Jack-DC; BARREL_JACK_PJ102B; MPN PJ-102B
J4, J12, J17, J19: Conn_Coaxial; LEMO_straight; MPN EPA.00.250.NTN
J5: RJ45; RJ45_8_A00-108-262-450; MPN A00-108-262-450
J24: Conn_01x02; Pin_Header_Angled_1x02_Pitch2.54mm; MPN 640455-2
R1, R20, R61, R71: 50; R_0805

Connections:
/Amplifier 2/AMP_IN: J2.1 (In); also elsewhere on the board
/Amplifier 2/AMP_OUT: R20.1; also elsewhere on the board
/Amplifier 3/AMP_IN: J16.1 (In); also elsewhere on the board
/Amplifier 3/AMP_OUT: R61.1; also elsewhere on the board
/Amplifier 4/AMP_IN: J18.1 (In); also elsewhere on the board
/Amplifier 4/AMP_OUT: R71.1; also elsewhere on the board
/Amplifier/AMP_IN: J1.1 (In); also elsewhere on the board
/Amplifier/AMP_OUT: R1.1; also elsewhere on the board
/Discriminator 2/LVDS_OUT_+: J5.4; also elsewhere on the board
/Discriminator 2/LVDS_OUT_-: J5.3; also elsewhere on the board
/Discriminator 3/LVDS_OUT_+: J5.6; also elsewhere on the board
/Discriminator 3/LVDS_OUT_-: J5.5; also elsewhere on the board
/Discriminator 4/LVDS_OUT_+: J5.8; also elsewhere on the board
/Discriminator 4/LVDS_OUT_-: J5.7; also elsewhere on the board
/Discriminator/LVDS_OUT_+: J5.2; also elsewhere on the board
/Discriminator/LVDS_OUT_-: J5.1; also elsewhere on the board
/Logic/TRIG: J13.1 (In); also elsewhere on the board
/Logic/TRIG_LVDS_+: J24.1; also elsewhere on the board
/Logic/TRIG_LVDS_-: J24.2; also elsewhere on the board
/Power/GND_RAW: J3.2; also elsewhere on the board
/Power/VIN_24V_RAW: J3.1; also elsewhere on the board
GND: C229.2, C230.2, J1.2 (Ext), J2.2 (Ext), J4.2 (Ext), J12.2 (Ext), J13.2 (Ext), J16.2 (Ext), J17.2 (Ext), J18.2 (Ext), J19.2 (Ext); also elsewhere on the board
unnamed: C229.1, C230.1, J5.9 (SHIELD)
unnamed: J4.1 (In), R1.2
unnamed: J12.1 (In), R20.2
unnamed: J17.1 (In), R61.2
unnamed: J19.1 (In), R71.2

Parts:
C23, C24, C30, C31, C38, C39, C46, C47, C107, C108: 2.2u; C_0402; MPN GRM155R61C225KE11DDDD
C25, C26, C27, C28, C32, C33, C34, C35, C36, C40, C41, C43, C44, C49, C50, C51, C52, C109, C110, C111, C112: 2.2n; C_0306; MPN LLL185R71H222MA01
C29, C42: 30p; C_0603; MPN GRM0335C1H300JA01D
C37: 1u; C_0603
C48: 100p; C_0603; MPN C0603C101J5GACTU
L6, L7, L8, L9, L10, L11, L12, L13, L22, L23: 1k@100MHz; L_1210; MPN FB MH3225HM601NT
R11: 50; R_0805
R12, R13, R16, R17: 39; R_0603; MPN RC0603FR-0739RL
R14: 470; R_0603; MPN RC0603FR-07470RL
R15: 3.3k; C_0805
R18: 470; R_0402; MPN RC0402FR-07470RL
R48: 1k; C_0805
U2, U4, U22: BUF602; SOT-23-5; MPN BUF602IDBVT
U3, U5: OPA847; SOT-23-6; MPN OPA847IDBVT

Connections:
+5V: L6.2, L8.2, L10.2, L12.2, L22.2; also elsewhere on the board
-5V: L7.2, L9.2, L11.2, L13.2, L23.2; also elsewhere on the board
/Amplifier/AMP_IN: R11.1, U2.4 (In); also elsewhere on the board
/Amplifier/AMP_OUT: U22.1 (out); also elsewhere on the board
/Amplifier/buf602_0_V+: C23.1, C25.1, C27.1, L6.1, U2.5 (+V)
/Amplifier/buf602_0_V-: C24.1, C26.1, C28.1, L7.1, U2.2 (V-)
/Amplifier/buf602_1_V+: C38.1, C40.1, C43.1, L10.1, U4.5 (+V)
/Amplifier/buf602_1_V-: C39.1, C41.1, C44.1, L11.1, U4.2 (V-)
/Amplifier/buf602_2_V+: C107.1, C109.1, C111.1, L22.1, U22.5 (+V)
/Amplifier/buf602_2_V-: C108.1, C110.1, C112.1, L23.1, U22.2 (V-)
/Amplifier/opa847_0_V+: C30.1, C32.1, C34.1, L8.1, U3.6 (+V)
/Amplifier/opa847_0_V-: C31.1, C33.1, C35.1, L9.1, U3.2 (V-)
/Amplifier/opa847_1_V+: C46.1, C49.1, C51.1, L12.1, U5.6 (+V)
/Amplifier/opa847_1_V-: C47.1, C50.1, C52.1, L13.1, U5.2 (V-)
GND: C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C46.2, C47.2, C49.2, C50.2, C51.2, C52.2, C107.2, C108.2, C109.2, C110.2, C111.2, C112.2, R11.2, R13.2, R16.1, R17.1, R48.2; also elsewhere on the board
unnamed: C29.1, R13.1, U3.3 (+)
unnamed: C36.1, R14.1, U3.1 (out)
unnamed: C36.2, R15.1, U4.4 (In)
unnamed: C37.1, R15.2, U4.3 (Ref)
unnamed: C42.1, R17.2, U4.1 (out), U5.3 (+)
unnamed: C48.1, R18.1, U5.1 (out)
unnamed: C48.2, R48.1, U22.4 (In)
unnamed: R12.1, R14.2, U3.4 (-)
unnamed: R12.2, U2.1 (out)
unnamed: R16.2, R18.2, U5.4 (-)

Parts of its further copies:
C76, C77, C78, C84, C85, C92, C93, C100, C101, C113, C114, C131, C137, C138, C145, C146, C153, C154, C160, C161, C166, C167, C173, C174, C181, C182, C189, C190, C196, C197: 2.2u; C_0402; MPN GRM155R61C225KE11DDDD
C79, C80, C81, C82, C86, C87, C88, C89, C90, C94, C95, C97, C98, C103, C104, C105, C106, C115, C116, C117, C118, C132, C133, C134, C135, C139, C140, C141, C142, C143, C147, C148, C150, C151, C156, C157, C158, C159, C162, C163, C164, C165, C168, C169, C170, C171, C175, C176, C177, C178, C179, C183, C184, C186, C187, C192, C193, C194, C195, C198, C199, C200, C201: 2.2n; C_0306; MPN LLL185R71H222MA01
C83, C96, C136, C149, C172, C185: 30p; C_0603; MPN GRM0335C1H300JA01D
C91, C144, C180: 1u; C_0603
C102, C155, C191: 100p; C_0603; MPN C0603C101J5GACTU
L14, L15, L16, L17, L18, L19, L20, L21, L24, L25, L26, L27, L28, L29, L30, L31, L32, L33, L34, L35, L36, L37, L38, L39, L40, L41, L42, L43, L44, L45: 1k@100MHz; L_1210; MPN FB MH3225HM601NT
R40, R62, R72: 50; R_0805
R41, R42, R45, R46, R63, R64, R67, R68, R73, R74, R77, R78: 39; R_0603; MPN RC0603FR-0739RL
R43, R65, R75: 470; R_0603; MPN RC0603FR-07470RL
R44, R66, R76: 3.3k; C_0805
R47, R69, R79: 470; R_0402; MPN RC0402FR-07470RL
R49, R70, R80: 1k; C_0805
U18, U20, U23, U33, U35, U37, U38, U40, U42: BUF602; SOT-23-5; MPN BUF602IDBVT
U19, U21, U34, U36, U39, U41: OPA847; SOT-23-6; MPN OPA847IDBVT

Connections of its further copies:
+5V: L14.2, L16.2, L18.2, L20.2, L24.2, L26.2, L28.2, L30.2, L32.2, L34.2, L36.2, L38.2, L40.2, L42.2, L44.2; also elsewhere on the board
-5V: L15.2, L17.2, L19.2, L21.2, L25.2, L27.2, L29.2, L31.2, L33.2, L35.2, L37.2, L39.2, L41.2, L43.2, L45.2; also elsewhere on the board
/Amplifier 2/AMP_IN: R40.1, U18.4 (In); also elsewhere on the board
/Amplifier 2/AMP_OUT: U23.1 (out); also elsewhere on the board
/Amplifier 2/buf602_0_V+: C77.1, C79.1, C81.1, L14.1, U18.5 (+V)
/Amplifier 2/buf602_0_V-: C78.1, C80.1, C82.1, L15.1, U18.2 (V-)
/Amplifier 2/buf602_1_V+: C92.1, C94.1, C97.1, L18.1, U20.5 (+V)
/Amplifier 2/buf602_1_V-: C93.1, C95.1, C98.1, L19.1, U20.2 (V-)
/Amplifier 2/buf602_2_V+: C113.1, C115.1, C117.1, L24.1, U23.5 (+V)
/Amplifier 2/buf602_2_V-: C114.1, C116.1, C118.1, L25.1, U23.2 (V-)
/Amplifier 2/opa847_0_V+: C84.1, C86.1, C88.1, L16.1, U19.6 (+V)
/Amplifier 2/opa847_0_V-: C85.1, C87.1, C89.1, L17.1, U19.2 (V-)
/Amplifier 2/opa847_1_V+: C100.1, C103.1, C105.1, L20.1, U21.6 (+V)
/Amplifier 2/opa847_1_V-: C101.1, C104.1, C106.1, L21.1, U21.2 (V-)
/Amplifier 3/AMP_IN: R62.1, U33.4 (In); also elsewhere on the board
/Amplifier 3/AMP_OUT: U37.1 (out); also elsewhere on the board
/Amplifier 3/buf602_0_V+: C76.1, C132.1, C134.1, L26.1, U33.5 (+V)
/Amplifier 3/buf602_0_V-: C131.1, C133.1, C135.1, L27.1, U33.2 (V-)
/Amplifier 3/buf602_1_V+: C145.1, C147.1, C150.1, L30.1, U35.5 (+V)
/Amplifier 3/buf602_1_V-: C146.1, C148.1, C151.1, L31.1, U35.2 (V-)
/Amplifier 3/buf602_2_V+: C160.1, C162.1, C164.1, L34.1, U37.5 (+V)
/Amplifier 3/buf602_2_V-: C161.1, C163.1, C165.1, L35.1, U37.2 (V-)
/Amplifier 3/opa847_0_V+: C137.1, C139.1, C141.1, L28.1, U34.6 (+V)
/Amplifier 3/opa847_0_V-: C138.1, C140.1, C142.1, L29.1, U34.2 (V-)
/Amplifier 3/opa847_1_V+: C153.1, C156.1, C158.1, L32.1, U36.6 (+V)
/Amplifier 3/opa847_1_V-: C154.1, C157.1, C159.1, L33.1, U36.2 (V-)
/Amplifier 4/AMP_IN: R72.1, U38.4 (In); also elsewhere on the board
/Amplifier 4/AMP_OUT: U42.1 (out); also elsewhere on the board
/Amplifier 4/buf602_0_V+: C166.1, C168.1, C170.1, L36.1, U38.5 (+V)
/Amplifier 4/buf602_0_V-: C167.1, C169.1, C171.1, L37.1, U38.2 (V-)
/Amplifier 4/buf602_1_V+: C181.1, C183.1, C186.1, L40.1, U40.5 (+V)
/Amplifier 4/buf602_1_V-: C182.1, C184.1, C187.1, L41.1, U40.2 (V-)
/Amplifier 4/buf602_2_V+: C196.1, C198.1, C200.1, L44.1, U42.5 (+V)
/Amplifier 4/buf602_2_V-: C197.1, C199.1, C201.1, L45.1, U42.2 (V-)
/Amplifier 4/opa847_0_V+: C173.1, C175.1, C177.1, L38.1, U39.6 (+V)
/Amplifier 4/opa847_0_V-: C174.1, C176.1, C178.1, L39.1, U39.2 (V-)
/Amplifier 4/opa847_1_V+: C189.1, C192.1, C194.1, L42.1, U41.6 (+V)
/Amplifier 4/opa847_1_V-: C190.1, C193.1, C195.1, L43.1, U41.2 (V-)
GND: C76.2, C77.2, C78.2, C79.2, C80.2, C81.2, C82.2, C83.2, C84.2, C85.2, C86.2, C87.2, C88.2, C89.2, C91.2, C92.2, C93.2, C94.2, C95.2, C96.2, C97.2, C98.2, C100.2, C101.2, C103.2, C104.2, C105.2, C106.2, C113.2, C114.2, C115.2, C116.2, C117.2, C118.2, C131.2, C132.2, C133.2, C134.2, C135.2, C136.2, C137.2, C138.2, C139.2, C140.2, C141.2, C142.2, C144.2, C145.2, C146.2, C147.2, C148.2, C149.2, C150.2, C151.2, C153.2, C154.2, C156.2, C157.2, C158.2, C159.2, C160.2, C161.2, C162.2, C163.2, C164.2, C165.2, C166.2, C167.2, C168.2, C169.2, C170.2, C171.2, C172.2, C173.2, C174.2, C175.2, C176.2, C177.2, C178.2, C180.2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; also elsewhere on the board
unnamed: C83.1, R42.1, U19.3 (+)
unnamed: C90.1, R43.1, U19.1 (out)
unnamed: C90.2, R44.1, U20.4 (In)
unnamed: C91.1, R44.2, U20.3 (Ref)
unnamed: C96.1, R46.2, U20.1 (out), U21.3 (+)
unnamed: C102.1, R47.1, U21.1 (out)
unnamed: C102.2, R49.1, U23.4 (In)
unnamed: C136.1, R64.1, U34.3 (+)
unnamed: C143.1, R65.1, U34.1 (out)
unnamed: C143.2, R66.1, U35.4 (In)
unnamed: C144.1, R66.2, U35.3 (Ref)
unnamed: C149.1, R68.2, U35.1 (out), U36.3 (+)
unnamed: C155.1, R69.1, U36.1 (out)
unnamed: C155.2, R70.1, U37.4 (In)
unnamed: C172.1, R74.1, U39.3 (+)
unnamed: C179.1, R75.1, U39.1 (out)
unnamed: C179.2, R76.1, U40.4 (In)
unnamed: C180.1, R76.2, U40.3 (Ref)
unnamed: C185.1, R78.2, U40.1 (out), U41.3 (+)
unnamed: C191.1, R79.1, U41.1 (out)
unnamed: C191.2, R80.1, U42.4 (In)
unnamed: R41.1, R43.2, U19.4 (-)
unnamed: R41.2, U18.1 (out)
unnamed: R45.2, R47.2, U21.4 (-)
unnamed: R63.1, R65.2, U34.4 (-)
unnamed: R63.2, U33.1 (out)
unnamed: R67.2, R69.2, U36.4 (-)
unnamed: R73.1, R75.2, U39.4 (-)
unnamed: R73.2, U38.1 (out)
unnamed: R77.2, R79.2, U41.4 (-)

Parts:
C53, C57: 47u; R_0805_HandSoldering
C54: 100n; C_0603
C55, C56, C58, C59, C60, C62, C63: 10u; R_0612; MPN LLL31MR70J475MA01L
C61: 100p; C_0603; MPN C0603C101J5GACTU
C64, C231: 2.2u; C_0402_NoSilk; MPN GRM155R61C225KE11DDDD
D3, D4: D; SOD-523; MPN 1SS387,L3F
D5, D6: D_Schottky; D_MiniMELF; MPN LL101C-GS08
R19: 6.8k; R_0805
R22, R109: 1k; R_0805
R23: 200; R_0805
R24, R26: 82.5; R_0603; MPN RC0603FR-0782R5L
R25, R27, R105: 124; R_0603; MPN RC0603FR-07124RL
RV1: 10k; Potentiometer_Trimmer_Bourns_3266W; MPN 3266W-1-103LF
RV2: 50k; Potentiometer_Trimmer_Bourns_3266W; MPN 3266W-1-503LF
TP13: TEST; Testpoint_Keystone_11011; MPN 11011-R
U6: TS5A623157; MSOP-10_3x3mm_Pitch0.5mm; MPN TS5A62315DGSR
U7: MCP6001; SOT-23-5_HandSoldering; MPN MCP6001T-I/OT
U8: SN74LVC1G17; SOT-23-5_HandSoldering; MPN SN74LVC1G17DBVR
U9: MAX9378; TSSOP-8_3x3mm_Pitch0.65mm; MPN MAX9378EUA+
U10: ADCMP553; MSOP-8_3x3mm_Pitch0.65mm; MPN ADCMP553BRMZ
U11: MC100ELT21; SOIC-8_3.9x4.9mm_Pitch1.27mm; MPN MC100ELT21DG
U31: TC7SZ125FULJ; SOT-353_SC-70-5

Connections:
+5V: C55.1, C56.1, C58.1, C59.1, C60.1, C62.1, C63.1, C64.1, R19.1, R24.1, R26.1, U6.8 (V+), U7.5 (V+), U8.5 (Vcc), U9.8 (Vcc), U10.7 (Vcc), U11.8 (Vcc), U31.5 (VCC); also elsewhere on the board
/Amplifier/AMP_OUT: R105.1; also elsewhere on the board
/Discriminator/LVDS_OUT_+: U9.7 (OUT); also elsewhere on the board
/Discriminator/LVDS_OUT_-: U9.6 (OUT_); also elsewhere on the board
/Jumper/TTL_IN: U31.4 (OUT_Y); also elsewhere on the board
GND: C53.2, C54.2, C55.2, C56.2, C57.2, C58.2, C59.2, C60.2, C61.2, C62.2, C63.2, C64.2, C231.2, D4.1 (K), D5.2 (A), R25.2, R27.2, R109.2, RV1.3, U6.3 (GND), U7.2 (V-), U8.3 (GND), U9.4 (GND), U10.8 (GND), U11.5 (GND), U31.1 (~G), U31.3 (GND); also elsewhere on the board
unnamed: C54.1, RV1.2, U7.3 (+)
unnamed: C61.1, D6.2 (A), R23.2, U8.2 (A)
unnamed: C231.1, R22.1, TP13.1, U10.4 (IN-)
unnamed: D3.1 (K), D4.2 (A)
unnamed: D3.2 (A), D5.1 (K), R105.2, U10.3 (IN+)
unnamed: D6.1 (K), R109.1, RV2.1, U11.7 (Q), U31.2 (IN_A)
unnamed: R19.2, RV1.1
unnamed: R22.2, U7.1, U7.4 (-)
unnamed: R23.1, RV2.2, RV2.3
unnamed: R24.2, R25.1, U6.9 (NC1), U9.2 (IN), U10.6 (Q), U11.2 (D)
unnamed: R26.2, R27.1, U6.7 (NC2), U9.3 (IN_), U10.5 (Q_), U11.3 (D_)
unnamed: U6.1 (IN1), U6.5 (IN2), U8.4 (Y)
unnamed: U6.10 (COM1), U10.1 (LEA_)
unnamed: U6.6 (COM2), U10.2 (LEA)
PECL_high: C53.1, U6.4 (NO2); also elsewhere on the board
PECL_low: C57.1, U6.2 (NO1); also elsewhere on the board

Parts of its further copies:
C119, C123, C202, C206, C214, C218: 47u; R_0805_HandSoldering
C120, C203, C215: 100n; C_0603
C121, C122, C124, C125, C126, C128, C129, C204, C205, C207, C208, C209, C211, C212, C216, C217, C219, C220, C221, C223, C224: 10u; R_0612; MPN LLL31MR70J475MA01L
C127, C210, C222: 100p; C_0603; MPN C0603C101J5GACTU
C130, C213, C225, C232, C233, C234: 2.2u; C_0402_NoSilk; MPN GRM155R61C225KE11DDDD
D7, D8, D11, D12, D15, D16: D; SOD-523; MPN 1SS387,L3F
D9, D10, D13, D14, D17, D18: D_Schottky; D_MiniMELF; MPN LL101C-GS08
R21, R81, R88: 6.8k; R_0805
R50, R82, R89, R110, R111, R112: 1k; R_0805
R51, R83, R90: 200; R_0805
R52, R54, R84, R86, R91, R93: 82.5; R_0603; MPN RC0603FR-0782R5L
R53, R55, R85, R87, R92, R94, R106, R107, R108: 124; R_0603; MPN RC0603FR-07124RL
RV7, RV10, RV12: 10k; Potentiometer_Trimmer_Bourns_3266W; MPN 3266W-1-103LF
RV8, RV11, RV13: 50k; Potentiometer_Trimmer_Bourns_3266W; MPN 3266W-1-503LF
TP15, TP17, TP19: TEST; Testpoint_Keystone_11011; MPN 11011-R
U24, U43, U49: TS5A623157; MSOP-10_3x3mm_Pitch0.5mm; MPN TS5A62315DGSR
U25, U44, U50: MCP6001; SOT-23-5_HandSoldering; MPN MCP6001T-I/OT
U26, U45, U51: SN74LVC1G17; SOT-23-5_HandSoldering; MPN SN74LVC1G17DBVR
U27, U46, U52: MAX9378; TSSOP-8_3x3mm_Pitch0.65mm; MPN MAX9378EUA+
U28, U47, U53: ADCMP553; MSOP-8_3x3mm_Pitch0.65mm; MPN ADCMP553BRMZ
U29, U48, U54: MC100ELT21; SOIC-8_3.9x4.9mm_Pitch1.27mm; MPN MC100ELT21DG
U56, U57, U58: TC7SZ125FULJ; SOT-353_SC-70-5

Connections of its further copies:
+5V: C121.1, C122.1, C124.1, C125.1, C126.1, C128.1, C129.1, C130.1, C204.1, C205.1, C207.1, C208.1, C209.1, C211.1, C212.1, C213.1, C216.1, C217.1, C219.1, C220.1, C221.1, C223.1, C224.1, C225.1, R21.1, R52.1, R54.1, R81.1, R84.1, R86.1, R88.1, R91.1, R93.1, U24.8 (V+), U25.5 (V+), U26.5 (Vcc), U27.8 (Vcc), U28.7 (Vcc), U29.8 (Vcc), U43.8 (V+), U44.5 (V+), U45.5 (Vcc), U46.8 (Vcc), U47.7 (Vcc), U48.8 (Vcc), U49.8 (V+), U50.5 (V+), U51.5 (Vcc), U52.8 (Vcc), U53.7 (Vcc), U54.8 (Vcc), U56.5 (VCC), U57.5 (VCC), U58.5 (VCC); also elsewhere on the board
/Amplifier 2/AMP_OUT: R106.1; also elsewhere on the board
/Amplifier 3/AMP_OUT: R107.1; also elsewhere on the board
/Amplifier 4/AMP_OUT: R108.1; also elsewhere on the board
/Discriminator 2/LVDS_OUT_+: U27.7 (OUT); also elsewhere on the board
/Discriminator 2/LVDS_OUT_-: U27.6 (OUT_); also elsewhere on the board
/Discriminator 3/LVDS_OUT_+: U46.7 (OUT); also elsewhere on the board
/Discriminator 3/LVDS_OUT_-: U46.6 (OUT_); also elsewhere on the board
/Discriminator 4/LVDS_OUT_+: U52.7 (OUT); also elsewhere on the board
/Discriminator 4/LVDS_OUT_-: U52.6 (OUT_); also elsewhere on the board
/Jumper 2/TTL_IN: U56.4 (OUT_Y); also elsewhere on the board
/Jumper 3/TTL_IN: U57.4 (OUT_Y); also elsewhere on the board
/Jumper 4/TTL_IN: U58.4 (OUT_Y); also elsewhere on the board
GND: C119.2, C120.2, C121.2, C122.2, C123.2, C124.2, C125.2, C126.2, C127.2, C128.2, C129.2, C130.2, C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, C209.2, C210.2, C211.2, C212.2, C213.2, C214.2, C215.2, C216.2, C217.2, C218.2, C219.2, C220.2, C221.2, C222.2, C223.2, C224.2, C225.2, C232.2, C233.2, C234.2, D8.1 (K), D9.2 (A), D12.1 (K), D13.2 (A), D16.1 (K), D17.2 (A), R53.2, R55.2, R85.2, R87.2, R92.2, R94.2, R110.2, R111.2, R112.2, RV7.3, RV10.3, RV12.3, U24.3 (GND), U25.2 (V-), U26.3 (GND), U27.4 (GND), U28.8 (GND), U29.5 (GND), U43.3 (GND), U44.2 (V-), U45.3 (GND), U46.4 (GND), U47.8 (GND), U48.5 (GND), U49.3 (GND), U50.2 (V-), U51.3 (GND), U52.4 (GND), U53.8 (GND), U54.5 (GND), U56.1 (~G), U56.3 (GND), U57.1 (~G), U57.3 (GND), U58.1 (~G)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; also elsewhere on the board
unnamed: C120.1, RV7.2, U25.3 (+)
unnamed: C127.1, D10.2 (A), R51.2, U26.2 (A)
unnamed: C203.1, RV10.2, U44.3 (+)
unnamed: C210.1, D14.2 (A), R83.2, U45.2 (A)
unnamed: C215.1, RV12.2, U50.3 (+)
unnamed: C222.1, D18.2 (A), R90.2, U51.2 (A)
unnamed: C232.1, R50.1, TP15.1, U28.4 (IN-)
unnamed: C233.1, R82.1, TP17.1, U47.4 (IN-)
unnamed: C234.1, R89.1, TP19.1, U53.4 (IN-)
unnamed: D7.1 (K), D8.2 (A)
unnamed: D7.2 (A), D9.1 (K), R106.2, U28.3 (IN+)
unnamed: D10.1 (K), R110.1, RV8.1, U29.7 (Q), U56.2 (IN_A)
unnamed: D11.1 (K), D12.2 (A)
unnamed: D11.2 (A), D13.1 (K), R107.2, U47.3 (IN+)
unnamed: D14.1 (K), R111.1, RV11.1, U48.7 (Q), U57.2 (IN_A)
unnamed: D15.1 (K), D16.2 (A)
unnamed: D15.2 (A), D17.1 (K), R108.2, U53.3 (IN+)
unnamed: D18.1 (K), R112.1, RV13.1, U54.7 (Q), U58.2 (IN_A)
unnamed: R21.2, RV7.1
unnamed: R50.2, U25.1, U25.4 (-)
unnamed: R51.1, RV8.2, RV8.3
unnamed: R52.2, R53.1, U24.9 (NC1), U27.2 (IN), U28.6 (Q), U29.2 (D)
unnamed: R54.2, R55.1, U24.7 (NC2), U27.3 (IN_), U28.5 (Q_), U29.3 (D_)
unnamed: R81.2, RV10.1
unnamed: R82.2, U44.1, U44.4 (-)
unnamed: R83.1, RV11.2, RV11.3
unnamed: R84.2, R85.1, U43.9 (NC1), U46.2 (IN), U47.6 (Q), U48.2 (D)
unnamed: R86.2, R87.1, U43.7 (NC2), U46.3 (IN_), U47.5 (Q_), U48.3 (D_)
unnamed: R88.2, RV12.1
unnamed: R89.2, U50.1, U50.4 (-)
unnamed: R90.1, RV13.2, RV13.3
unnamed: R91.2, R92.1, U49.9 (NC1), U52.2 (IN), U53.6 (Q), U54.2 (D)
unnamed: R93.2, R94.1, U49.7 (NC2), U52.3 (IN_), U53.5 (Q_), U54.3 (D_)
unnamed: U24.1 (IN1), U24.5 (IN2), U26.4 (Y)
unnamed: U24.6 (COM2), U28.2 (LEA)
unnamed: U24.10 (COM1), U28.1 (LEA_)
unnamed: U43.1 (IN1), U43.5 (IN2), U45.4 (Y)
unnamed: U43.6 (COM2), U47.2 (LEA)
unnamed: U43.10 (COM1), U47.1 (LEA_)
unnamed: U49.1 (IN1), U49.5 (IN2), U51.4 (Y)
unnamed: U49.6 (COM2), U53.2 (LEA)
unnamed: U49.10 (COM1), U53.1 (LEA_)
PECL_high: C119.1, C202.1, C214.1, U24.4 (NO2), U43.4 (NO2), U49.4 (NO2); also elsewhere on the board
PECL_low: C123.1, C206.1, C218.1, U24.2 (NO1), U43.2 (NO1), U49.2 (NO1); also elsewhere on the board

Parts:
J6, J7: Conn_Coaxial; LEMO_straight; MPN EPA.00.250.NTN
JP1: Jumper; Pin_Header_Straight_1x02_Pitch2.54mm
R95: 50; R_0805

Connections:
/Jumper/TTL_IN: J6.1 (In), JP1.1; also elsewhere on the board
/Logic/PAIR_A_1: J7.1 (In), JP1.2, R95.1; also elsewhere on the board
GND: J6.2 (Ext), J7.2 (Ext), R95.2; also elsewhere on the board

Parts of its further copies:
J14, J15, J20, J21, J22, J23: Conn_Coaxial; LEMO_straight; MPN EPA.00.250.NTN
JP2, JP3, JP4: Jumper; Pin_Header_Straight_1x02_Pitch2.54mm
R96, R97, R98: 50; R_0805

Connections of its further copies:
/Jumper 2/TTL_IN: J14.1 (In), JP2.1; also elsewhere on the board
/Jumper 3/TTL_IN: J20.1 (In), JP3.1; also elsewhere on the board
/Jumper 4/TTL_IN: J22.1 (In), JP4.1; also elsewhere on the board
/Logic/PAIR_A_2: J15.1 (In), JP2.2, R96.1; also elsewhere on the board
/Logic/PAIR_B_1: J21.1 (In), JP3.2, R97.1; also elsewhere on the board
/Logic/PAIR_B_2: J23.1 (In), JP4.2, R98.1; also elsewhere on the board
GND: J14.2 (Ext), J15.2 (Ext), J20.2 (Ext), J21.2 (Ext), J22.2 (Ext), J23.2 (Ext), R96.2, R97.2, R98.2; also elsewhere on the board

Parts:
C65, C66, C67, C68: 1n; C_0805_HandSoldering
J8, J9, J10, J11: Screw_Terminal_01x04; TerminalBlock_Pheonix_MPT-2.54mm_4pol; MPN OSTVN04A150
R56, R57, R58, R59: 7.15k; R_0805
RV3, RV4, RV5, RV6: 10k; Potentiometer_Trimmer_Bourns_3266W; MPN 3266W-1-103LF

Connections:
+15V: J8.1, J9.1, J10.1, J11.1; also elsewhere on the board
GND: C65.2, C66.2, C67.2, C68.2, J8.4, J9.4, J10.4, J11.4, R56.2, R57.2, R58.2, R59.2; also elsewhere on the board
unnamed: C65.1, J8.3, RV3.2
unnamed: C66.1, J9.3, RV4.2
unnamed: C67.1, J10.3, RV5.2
unnamed: C68.1, J11.3, RV6.2
unnamed: J8.2, RV3.3
unnamed: J9.2, RV4.3
unnamed: J10.2, RV5.3
unnamed: J11.2, RV6.3
unnamed: R56.1, RV3.1
unnamed: R57.1, RV4.1
unnamed: R58.1, RV5.1
unnamed: R59.1, RV6.1

Parts:
C21, C22, C75: 620p; C_1206; MPN C1206C621G5GACTU
C69, C70, C71, C72, C73, C74, C226, C227, C228: 1u; C_0603_HandSoldering
JP5, JP6, JP7: Jumper_NC_Dual; Pin_Header_Straight_1x03_Pitch2.54mm
R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39: 10k; R_0603_HandSoldering; MPN RC0603JR-0710KL
R60: 50; R_0805
R102, R103, R104: 1k; R_0805
RV9, RV14, RV15: 10k; Potentiometer_Trimmer_Bourns_3266W; MPN 3266W-1-103LF
TP5, TP12: TEST; Testpoint_Keystone_11011; MPN 11011-R
U12, U13, U17: 206-4ST; SW_DIP_x4_W7.62mm_Slide; MPN 206-4ST
U14, U15: MAX4634; MSOP-10_3x3mm_Pitch0.5mm
U16: MAX4634; MSOP-10_3x3mm_Pitch0.5mm; MPN MAX4634EUB+T
U30, U32: 74HC123A; SOIC-16_3.9x9.9mm_Pitch1.27mm; MPN SN74AHCT123AD
U55: DS90LV019; SOIC-14_3.9x8.7mm_Pitch1.27mm

Connections:
+5V: C69.1, C70.1, C71.1, C72.1, C73.1, C74.1, C226.1, C227.1, C228.1, RV9.1, RV14.1, RV15.1, U12.1 (1_IN), U12.2 (2_IN), U12.3 (3_IN), U12.4 (4_IN), U13.1 (1_IN), U13.2 (2_IN), U13.3 (3_IN), U13.4 (4_IN), U14.5 (EN), U14.6 (V+), U15.5 (EN), U15.6 (V+), U16.5 (EN), U16.6 (V+), U17.1 (1_IN), U17.2 (2_IN), U17.3 (3_IN), U17.4 (4_IN), U30.3 (1~CLR), U30.11 (2~CLR), U30.16 (Vcc), U32.3 (1~CLR), U32.16 (Vcc), U55.1 (DE), U55.5 (NC), U55.8 (~RE), U55.14 (VCC); also elsewhere on the board
/Logic/PAIR_A_1: U14.10 (A1); also elsewhere on the board
/Logic/PAIR_A_2: U14.1 (A0); also elsewhere on the board
/Logic/PAIR_B_1: U15.10 (A1); also elsewhere on the board
/Logic/PAIR_B_2: U15.1 (A0); also elsewhere on the board
/Logic/TRIG: R60.2; also elsewhere on the board
/Logic/TRIG_LVDS_+: U55.12 (DO+); also elsewhere on the board
/Logic/TRIG_LVDS_-: U55.11 (DO-); also elsewhere on the board
GND: C69.2, C70.2, C71.2, C72.2, C73.2, C74.2, C226.2, C227.2, C228.2, R28.2, R29.2, R30.2, R31.2, R32.2, R33.2, R34.2, R35.2, R36.2, R37.2, R38.2, R39.2, R102.2, R103.2, R104.2, U14.3 (GND), U15.3 (GND), U16.3 (GND), U30.1 (1~A), U30.8 (GND), U30.9 (2~A), U32.1 (1~A), U32.8 (GND), U55.7 (GND); also elsewhere on the board
unnamed: C21.1, RV14.2, RV14.3, U30.7 (2Rx/Cx)
unnamed: C21.2, U30.6 (2Cx)
unnamed: C22.1, RV15.2, RV15.3, U30.15 (1Rx/Cx)
unnamed: C22.2, U30.14 (1Cx)
unnamed: C75.1, RV9.2, RV9.3, U32.15 (1Rx/Cx)
unnamed: C75.2, U32.14 (1Cx)
unnamed: JP5.1, U30.5 (2Q)
unnamed: JP5.2, TP5.1, U16.10 (A1)
unnamed: JP5.3, R102.1, U14.8 (COM), U30.10 (2B)
unnamed: JP6.1, U30.13 (1Q)
unnamed: JP6.2, TP12.1, U16.1 (A0)
unnamed: JP6.3, R103.1, U15.8 (COM), U30.2 (1B)
unnamed: JP7.1, U32.13 (1Q)
unnamed: JP7.2, R60.1, U55.2 (Din)
unnamed: JP7.3, R104.1, U16.8 (COM), U32.2 (1B)
unnamed: R28.1, U12.5 (4_OUT), U14.7 (NO4)
unnamed: R29.1, U13.5 (4_OUT), U15.7 (NO4)
unnamed: R30.1, U12.6 (3_OUT), U14.9 (NO2)
unnamed: R31.1, U13.6 (3_OUT), U15.9 (NO2)
unnamed: R32.1, U12.7 (2_OUT), U14.4 (NO3)
unnamed: R33.1, U13.7 (2_OUT), U15.4 (NO3)
unnamed: R34.1, U12.8 (1_OUT), U14.2 (NO1)
unnamed: R35.1, U13.8 (1_OUT), U15.2 (NO1)
unnamed: R36.1, U16.7 (NO4), U17.5 (4_OUT)
unnamed: R37.1, U16.9 (NO2), U17.6 (3_OUT)
unnamed: R38.1, U16.4 (NO3), U17.7 (2_OUT)
unnamed: R39.1, U16.2 (NO1), U17.8 (1_OUT)
