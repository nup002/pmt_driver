# Repository nup002/pmt_driver (continued)

## KiCad design pmt_driver.kicad_pcb (continued)

Parts:
C1, C2: 330u; CP_Radial_D10.0mm_P5.00mm; MPN ECA-1HM331
C3, C5: 4.7u; C_1206_HandSoldering; MPN UMK316ABJ475KD-T
C4, C20: 100u; CP_Radial_D8.0mm_P3.50mm; MPN UVz1H101MPD1TD
C6, C7, C8, C9: 100u; CP_Radial_D8.0mm_P5.00mm; MPN EEU-FM1H101B
C10, C11, C12, C13: 100u; C_1206_HandSoldering; MPN C3216X5R1A107M160AC
C14: 1n; R_1206_HandSoldering; MPN 202R18W102KV4E
C15, C16, C17, C18: 10u; C_0805_HandSoldering; MPN C0805C106K8PACTU
C19: 12u; C_Radial_D5_L11_P2; MPN UPW1V120MDD1TP
D1: D_TVS; DO-214AB; MPN SMCJ48A
D2: D; D_DO-41_SOD81_P10.16mm_Horizontal
D19, D20, D21: LED; LED_D5.0mm; MPN C503B-GCN-CY0C0791
D22: D; DO-214AB_Handsoldering; MPN S3M
F1: Fuse; Littelfuse_05200101Z_holder; MPN 05200101Z
L1: 56u; L_Toroid_Vertical_L22.4mm_W10.2mm_P7.90mm_Vishay_TJ4; MPN 2210-V-RC
L2: 12u; L_Radial_D10.0mm_P5.00mm_Fastron_07M; MPN RLB0914-120KL
L3: 12u; L_Radial_D6.0mm_P4.00mm; MPN AIUR-07-120K
L4, L5: 3u; L_Radial_D12.0mm_P6.5mm; MPN 74475
P1: JCH1024D05; MPN JCH1024D05
P2: PQMC3-D24-S15-S; PQMC3-S; MPN PQMC3-D24-S15-S
R2: 400m; R_0603_HandSoldering; MPN RL0603FR-070R4L
R3: 300m; R_2010_HandSoldering; MPN CSR2010JTR300
R4: 2.67k; R_0805_HandSoldering
R5, R6: 180m; R_1206_HandSoldering; MPN RL1206FR-070R18L
R7: 470; R_0805_HandSoldering
R8: 910; R_0805_HandSoldering
R9: 200; R_0805_HandSoldering
R10: 800; R_0805_HandSoldering
R99, R100: 90; C_0805
R101: 590; C_0805
TP10: TEST; Test_Point_Keystone_5000-5004_Miniature
U1: BB16AH

Connections:
+5V: C6.1, C8.1, C10.1, C12.1, C15.1, C17.1, L4.1, R7.1, R9.1, R99.2; also elsewhere on the board
+15V: C20.1, P2.6 (Vout+), R101.2; also elsewhere on the board
-5V: C7.2, C9.2, C11.1, C13.1, C16.1, C18.1, L5.1, R100.2; also elsewhere on the board
/Power/GND_RAW: C1.2, C2.2, C3.2, C4.2, C5.2, C14.2, D1.2, P1.2 (Vin-), P2.1 (GND), TP10.1; also elsewhere on the board
/Power/VIN_24V_RAW: F1.2; also elsewhere on the board
GND: C6.2, C7.1, C8.2, C9.1, C10.2, C11.2, C12.2, C13.2, C14.1, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, D19.1 (K), D20.2 (A), D21.1 (K), P1.4 (COM), P2.7 (0V), R8.2, R10.2; also elsewhere on the board
unnamed: C1.1, D1.1, D22.1 (K), R2.2, R3.2
unnamed: C2.1, C3.1, L1.1, L3.2
unnamed: C4.1, L2.1, P1.1 (Vin+)
unnamed: C5.1, D2.2 (A), L3.1, P2.2 (Vin+)
unnamed: C19.1, P2.8 (CS)
unnamed: D2.1 (K), R4.2
unnamed: D19.2 (A), R99.1
unnamed: D20.1 (K), R100.1
unnamed: D21.2 (A), R101.1
unnamed: D22.2 (A), F1.1
unnamed: L1.2, R2.1
unnamed: L2.2, R3.1
unnamed: L4.2, R5.1
unnamed: L5.2, R6.1
unnamed: P1.3 (Vout+), R5.2
unnamed: P1.5 (Vout-), R6.2
unnamed: P2.3 (Ctrl), U1.1 (Out_NC)
unnamed: R4.1, U1.2 (COM_1)
PECL_high: R9.2, R10.1; also elsewhere on the board
PECL_low: R7.2, R8.1; also elsewhere on the board

Parts:
TP1, TP2, TP3, TP4, TP6, TP7, TP8, TP9, TP11: TEST; Test_Point_Keystone_5000-5004_Miniature

Connections:
+5V: TP2.1; also elsewhere on the board
+15V: TP11.1; also elsewhere on the board
-5V: TP3.1; also elsewhere on the board
GND: TP1.1, TP4.1, TP6.1, TP7.1, TP8.1, TP9.1; also elsewhere on the board

Board: 4 copper layers, 249.5 x 160.0 mm, 537 parts (146 on the bottom side), 233 nets.

Other parts of the board:
C45, C99, C152, C188: 2.2u; C_0402_NoSilk
TP4#2: TEST; Test_Point_Keystone_5000-5004_Miniature

Their connections:
+5V: C45.1, C99.1, C152.1, C188.1; also elsewhere on the board
GND: C45.2, C99.2, C152.2, C188.2, TP4#2.1; also elsewhere on the board

## Commit log

2017-10-26 version 1
2017-10-30 v1.1
2017-11-13 Schematic fixes and creation of doumentation for mounting components.
2017-12-13 Several bug fixes and improvements.
2017-12-13 Fixed amplifier gain and bandwidth info on silkscreen.
2018-03-09 fixed panel cutout and added custom components and footprints
